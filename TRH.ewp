# IAR project TRH.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\Libraries\STM8S_StdPeriph_Driver\inc; TRH
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TRH.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group LIB
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_uart1.c
  group SRC
    ./: main.c
